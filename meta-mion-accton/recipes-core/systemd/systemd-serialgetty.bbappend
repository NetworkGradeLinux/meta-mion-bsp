SERIAL_CONSOLES_accton-wedge100bf-32x = "57600;ttyS0"
SERIAL_CONSOLES_accton-wedge100bf-65x = "57600;ttyS0"
